# Keil uVision project stm32h563_app_modbus.uvprojx, settings and files
target stm32h563_app_modbus (6210000::V6.21::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08020000-0x081FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: stm32h563_app_modbus +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_NON_SECURE=1,UX_INCLUDE_USER_DEFINE_FILE,USE_HAL_DRIVER,STM32H563xx,APP_STANDALONE_DEVELOPMENT=1
  c include: ../Core/Inc;../AZURE_RTOS/App;../USBX/App;../USBX/Target;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/threadx/common/inc;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../Middlewares/ST/usbx/common/core/inc;../Middlewares/ST/usbx/ports/generic/inc;../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../Middlewares/ST/usbx/common/usbx_device_classes/inc;../Drivers/CMSIS/Include;../Middlewares/ld_modbus/include;../Middlewares/ld_modbus/integrations/ldc;../Middlewares/ota;../user;../user/app;../user/bsp;../user/osal;../user/ldc/core;../user/shell;../user/usb;../user/at/core;../user/at/modules;..\Middlewares\ST\guix\common\inc;../user/ui/lvgl;../user/ui/lvgl/lvgl;../user/ui/lvgl/lvgl/src
  asm define: TX_SINGLE_MODE_NON_SECURE=1
  asm include: ../Core/Inc;../AZURE_RTOS/App;../USBX/App;../USBX/Target;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/threadx/common/inc;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../Middlewares/ST/usbx/common/core/inc;../Middlewares/ST/usbx/ports/generic/inc;../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../Middlewares/ST/usbx/common/usbx_device_classes/inc;../Drivers/CMSIS/Include;../Middlewares/ld_modbus/include;../Middlewares/ld_modbus/integrations/ldc;../Middlewares/ota;../user;../user/app;../user/bsp;../user/osal;../user/ldc/core;../user/shell;../user/usb;../user/at/core;../user/at/modules;../user/ui/lvgl;../user/ui/lvgl/lvgl;../user/ui/lvgl/lvgl/src
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c tx_initialize_low_level.S app_threadx.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/App
    ../user/app/: app_blackbox.c app_blackbox.h blackbox_store.c blackbox_store.h app_self_test.c app_self_test.h app_power.c app_power.h app_production_test.c app_production_test.h app_can_self_test.c app_can_self_test.h app_board_io.c app_board_io.h app_debug.c app_debug.h app_usb_service.c app_usb_service.h app_rs485.c app_rs485.h app_modbus_types.h app_w800.c app_w800.h app_w800_config.h app_w800_config_local.example.h app_shell.c app_shell.h app_config.h app_log.c app_log.h app_ota.c app_ota.h app_health.c app_health.h app_firmware_update_service.c app_firmware_update_service.h mqtt_packet.c mqtt_packet.h ota_layout.h
    ../Middlewares/ota/: ota_boot_control.c ota_boot_control.h ota_firmware_update.c ota_firmware_update.h ota_sha256.c ota_sha256.h
  group Application/Shell
    ../user/shell/: shell.c shell.h
  group Application/USB
    ../user/usb/: usb_console.c usb_console.h usb_vendor_protocol.c usb_vendor_protocol.h usb_vendor_transport.c usb_vendor_transport.h
    ../Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_activate.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_change.c ux_device_class_dpump_read.c ux_device_class_dpump_write.c
  group Application/UI/LVGL
    ../user/ui/lvgl/: app_ui.c app_ui.h app_ui_model.c app_ui_model.h lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h lv_conf.h sim_ui.c sim_ui.h boot_eye_img.c ui_asset_store.c ui_asset_store.h sim_data.c sim_data.h font_cjk_12.c font_cjk_14.c font_cjk_18.c font_cjk_20.c font_cjk_28.c
  group BSP/Device
    ../user/bsp/: bsp_lcd.c bsp_lcd.h gd25lq128.c gd25lq128.h bsp_touch.c bsp_touch.h
  group BSP/Common
    ../user/bsp/: bsp.c bsp.h bsp_dwt.c bsp_dwt.h bsp_timer.c bsp_timer.h bsp_pwm.c bsp_pwm.h bsp_fdcan.h bsp_rtc.h bsp_reset.h bsp_cache.h bsp_platform.h bsp_irq_lock.h bsp_spi.h bsp_i2c.h bsp_status.h bsp_clock.h bsp_uart.h
  group BSP/MCU
    ../user/bsp/: mcu_reset.c mcu_fdcan.c mcu_fdcan.h mcu_cache.c mcu_hal_timebase.c mcu_hal_timebase.h mcu_irq_lock.c mcu_spi.c mcu_spi.h mcu_i2c.c mcu_i2c.h mcu_pwm.c mcu_pwm.h mcu_clock.c mcu_uart.c mcu_uart.h
  group BSP/Board
    ../user/bsp/: bsp_board.c bsp_board.h bsp_led.c bsp_led.h board_fdcan.c board_rtc.c board_power.c bsp_power.h board_usb.c board_usb.h board_spi.c board_spi.h board_i2c.c board_gpio.c board_gpio.h board_uart.c board_uart.h board_resources.h
  group OSAL/ThreadX
    ../user/osal/: osal_mutex.h osal_threadx.c
  group Application/LDC
    ../user/ldc/core/: ldc_core.c ldc_core.h ldc_ring.c ldc_ring.h ldc_packet.c ldc_packet.h ldc_easy.c ldc_easy.h ldc_port_irq.h
  group Middleware/ld_modbus
    ../Middlewares/ld_modbus/src/: ld_modbus_core.c ld_modbus_client.c ld_modbus_server.c
    ../Middlewares/ld_modbus/integrations/ldc/: ld_modbus_ldc.c
  group Application/AT/Core
    ../user/at/core/: at_command_plan.c at_command_plan.h at_core.c at_core.h at_urc.c at_urc.h at_session.c at_session.h
  group Application/AT/Modules
    ../user/at/modules/: at_module.c at_module.h at_module_w800.c at_module_w800.h at_module_ec20.c at_module_ec20.h
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c app_usbx_device.c ux_device_cdc_acm.c
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c stm32h5xx_hal_i2c.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/ThreadX/Core
    ../Middlewares/ST/threadx/common/src/: tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_resume.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group Middlewares/USBX/UX Device Controllers
    ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/Core System
    ../Middlewares/ST/usbx/common/core/src/: ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/UX Device Class CDC ACM
    ../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_with_callback.c
  group Middlewares/LVGL
    ../user/ui/lvgl/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../user/ui/lvgl/lvgl/src/display/: lv_display.c
    ../user/ui/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../user/ui/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../user/ui/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../user/ui/lvgl/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../user/ui/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../user/ui/lvgl/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../user/ui/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../user/ui/lvgl/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../user/ui/lvgl/lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../user/ui/lvgl/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../user/ui/lvgl/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../user/ui/lvgl/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../user/ui/lvgl/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../user/ui/lvgl/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../user/ui/lvgl/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../user/ui/lvgl/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../user/ui/lvgl/lvgl/src/drivers/evdev/: lv_evdev.c
    ../user/ui/lvgl/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../user/ui/lvgl/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../user/ui/lvgl/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../user/ui/lvgl/lvgl/src/drivers/qnx/: lv_qnx.c
    ../user/ui/lvgl/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../user/ui/lvgl/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c
    ../user/ui/lvgl/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../user/ui/lvgl/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../user/ui/lvgl/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../user/ui/lvgl/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../user/ui/lvgl/lvgl/src/layouts/flex/: lv_flex.c
    ../user/ui/lvgl/lvgl/src/layouts/grid/: lv_grid.c
    ../user/ui/lvgl/lvgl/src/layouts/: lv_layout.c
    ../user/ui/lvgl/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../user/ui/lvgl/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../user/ui/lvgl/lvgl/src/libs/bmp/: lv_bmp.c
    ../user/ui/lvgl/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../user/ui/lvgl/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../user/ui/lvgl/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../user/ui/lvgl/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../user/ui/lvgl/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../user/ui/lvgl/lvgl/src/libs/libpng/: lv_libpng.c
    ../user/ui/lvgl/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../user/ui/lvgl/lvgl/src/libs/lz4/: lz4.c
    ../user/ui/lvgl/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../user/ui/lvgl/lvgl/src/libs/rle/: lv_rle.c
    ../user/ui/lvgl/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../user/ui/lvgl/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../user/ui/lvgl/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../user/ui/lvgl/lvgl/src/: lv_init.c
    ../user/ui/lvgl/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../user/ui/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../user/ui/lvgl/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ../user/ui/lvgl/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../user/ui/lvgl/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../user/ui/lvgl/lvgl/src/others/gridnav/: lv_gridnav.c
    ../user/ui/lvgl/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../user/ui/lvgl/lvgl/src/others/imgfont/: lv_imgfont.c
    ../user/ui/lvgl/lvgl/src/others/monkey/: lv_monkey.c
    ../user/ui/lvgl/lvgl/src/others/observer/: lv_observer.c
    ../user/ui/lvgl/lvgl/src/others/snapshot/: lv_snapshot.c
    ../user/ui/lvgl/lvgl/src/others/sysmon/: lv_sysmon.c
    ../user/ui/lvgl/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../user/ui/lvgl/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../user/ui/lvgl/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../user/ui/lvgl/lvgl/src/stdlib/: lv_mem.c
    ../user/ui/lvgl/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../user/ui/lvgl/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../user/ui/lvgl/lvgl/src/themes/default/: lv_theme_default.c
    ../user/ui/lvgl/lvgl/src/themes/: lv_theme.c
    ../user/ui/lvgl/lvgl/src/themes/mono/: lv_theme_mono.c
    ../user/ui/lvgl/lvgl/src/themes/simple/: lv_theme_simple.c
    ../user/ui/lvgl/lvgl/src/tick/: lv_tick.c
    ../user/ui/lvgl/lvgl/src/widgets/animimage/: lv_animimage.c
    ../user/ui/lvgl/lvgl/src/widgets/arc/: lv_arc.c
    ../user/ui/lvgl/lvgl/src/widgets/bar/: lv_bar.c
    ../user/ui/lvgl/lvgl/src/widgets/button/: lv_button.c
    ../user/ui/lvgl/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../user/ui/lvgl/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../user/ui/lvgl/lvgl/src/widgets/canvas/: lv_canvas.c
    ../user/ui/lvgl/lvgl/src/widgets/chart/: lv_chart.c
    ../user/ui/lvgl/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../user/ui/lvgl/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../user/ui/lvgl/lvgl/src/widgets/image/: lv_image.c
    ../user/ui/lvgl/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../user/ui/lvgl/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../user/ui/lvgl/lvgl/src/widgets/label/: lv_label.c
    ../user/ui/lvgl/lvgl/src/widgets/led/: lv_led.c
    ../user/ui/lvgl/lvgl/src/widgets/line/: lv_line.c
    ../user/ui/lvgl/lvgl/src/widgets/list/: lv_list.c
    ../user/ui/lvgl/lvgl/src/widgets/lottie/: lv_lottie.c
    ../user/ui/lvgl/lvgl/src/widgets/menu/: lv_menu.c
    ../user/ui/lvgl/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../user/ui/lvgl/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../user/ui/lvgl/lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../user/ui/lvgl/lvgl/src/widgets/roller/: lv_roller.c
    ../user/ui/lvgl/lvgl/src/widgets/scale/: lv_scale.c
    ../user/ui/lvgl/lvgl/src/widgets/slider/: lv_slider.c
    ../user/ui/lvgl/lvgl/src/widgets/span/: lv_span.c
    ../user/ui/lvgl/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../user/ui/lvgl/lvgl/src/widgets/spinner/: lv_spinner.c
    ../user/ui/lvgl/lvgl/src/widgets/switch/: lv_switch.c
    ../user/ui/lvgl/lvgl/src/widgets/table/: lv_table.c
    ../user/ui/lvgl/lvgl/src/widgets/tabview/: lv_tabview.c
    ../user/ui/lvgl/lvgl/src/widgets/textarea/: lv_textarea.c
    ../user/ui/lvgl/lvgl/src/widgets/tileview/: lv_tileview.c
    ../user/ui/lvgl/lvgl/src/widgets/win/: lv_win.c
software components: CMSIS:CORE 4.3.0
