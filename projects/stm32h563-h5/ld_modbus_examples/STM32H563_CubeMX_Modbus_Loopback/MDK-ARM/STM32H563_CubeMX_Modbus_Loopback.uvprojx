# Keil uVision project STM32H563_CubeMX_Modbus_Loopback.uvprojx, settings and files
target STM32H563_CubeMX_Modbus_Loopback (6140001::V6.14.1::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H563_CubeMX_Modbus_Loopback +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../App;../Tests;../Middlewares/ld_modbus/include;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcache.c icache.c memorymap.c tim.c usart.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/Modbus Loopback
    ../App/: modbus_example.c modbus_slave_example.c
    ../Tests/: modbus_loopback.c
  group Middlewares/ld_modbus
    ../Middlewares/ld_modbus/src/: ld_modbus_core.c ld_modbus_client.c ld_modbus_server.c ld_modbus_rtu_framer.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
