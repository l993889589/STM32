# Keil uVision project STM32H563_ld_modbus_app.uvprojx, settings and files
target STM32H563_ld_modbus_app (6210000::V6.21::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x081FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H563_ld_modbus_app
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../user/bsp;../user/app;../user/ldc/core;../user/ldc/ports/stm32;../user/osal;../Middlewares/ld_modbus/include;../Middlewares/ld_modbus/integrations/ldc
  asm define: USE_HAL_DRIVER,STM32H563xx
  asm include: as above
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Core
    ../Core/Src/: main.c gpio.c dcache.c icache.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Core/System
    ../Core/Src/: system_stm32h5xx.c
  group BSP/Common
    ../user/bsp/: bsp.c bsp_health.c bsp_dwt.c bsp_microtime.c
  group BSP/MCU
    ../user/bsp/: mcu_clock.c mcu_cpu_fault.c mcu_irq_lock.c mcu_time.c mcu_uart.c
  group BSP/Board
    ../user/bsp/: board_init.c board_control.c board_led.c board_uart.c
  group Application/Modbus
    ../user/app/: modbus_app.c
  group Middlewares/ld_modbus
    ../Middlewares/ld_modbus/src/: ld_modbus_client.c ld_modbus_core.c ld_modbus_server.c ld_modbus_rtu_framer.c
  group Middlewares/ld_modbus/LDC adapter
    ../Middlewares/ld_modbus/integrations/ldc/: ld_modbus_ldc.c
  group Application/LDC optional
    ../user/ldc/core/: ldc_core.c ldc_easy.c ldc_packet.c ldc_ring.c
  group Application/OSAL
    ../user/osal/: osal_bare_metal.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
