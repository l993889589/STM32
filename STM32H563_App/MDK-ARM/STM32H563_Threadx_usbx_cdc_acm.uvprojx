# Keil uVision project STM32H563_Threadx_usbx_cdc_acm.uvprojx, settings and files
target STM32H563_Threadx_usbx_cdc_acm (6210000::V6.21::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08020000-0x081FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H563_Threadx_usbx_cdc_acm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_NON_SECURE=1,UX_INCLUDE_USER_DEFINE_FILE,USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../AZURE_RTOS/App;../USBX/App;../USBX/Target;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/threadx/common/inc;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../Middlewares/ST/usbx/common/core/inc;../Middlewares/ST/usbx/ports/generic/inc;../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../Middlewares/ST/usbx/common/usbx_device_classes/inc;../Drivers/CMSIS/Include;../user;../user/app;../user/bsp;../user/ldc/core;../user/libmodbus;../../shared/shell;../user/usb;../user/at/core;../user/at/modules
  asm define: TX_SINGLE_MODE_NON_SECURE=1
  asm include: as above
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c tx_initialize_low_level.S gpio.c dcache.c gpdma.c icache.c memorymap.c spi.c app_threadx.c usart.c usb.c stm32h5xx_it.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c
  group Application/App
    ../user/app/: app_board_io.c app_board_io.h app_usb_service.c app_usb_service.h app_rs485.c app_rs485.h app_w800.c app_w800.h app_shell.c app_shell.h app_config.h app_msg_bus_service.c app_msg_bus_service.h app_event_bridge.c app_event_bridge.h app_ldc_config.c app_ldc_config.h app_nearlink.c app_nearlink.h app_ota.c app_ota.h mqtt_packet.c mqtt_packet.h ota_layout.h
    ../../shared/comm/msg_bus/: app_msg_bus.c app_msg_bus.h
  group Application/Shell
    ../../shared/shell/: shell.c shell.h
  group Application/USB
    ../user/usb/: usb_console.c usb_console.h usb_vendor_protocol.c usb_vendor_protocol.h usb_vendor_transport.c usb_vendor_transport.h
    ../Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_activate.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_change.c ux_device_class_dpump_read.c ux_device_class_dpump_write.c
  group Application/BSP
    ../user/bsp/: bsp.c bsp.h bsp_led.c bsp_led.h gd25lq128.c gd25lq128.h bsp_dwt.c bsp_dwt.h bsp_timer.c bsp_timer.h bsp_pwm.c bsp_pwm.h bsp_uart.c bsp_uart.h
  group Application/LDC
    ../user/ldc/core/: ldc_core.c ldc_core.h ldc_packet.c ldc_packet.h ldc_ring.c ldc_ring.h
    ../../shared/comm/ldc_endpoint/threadx/: ldc_endpoint_threadx.c ldc_endpoint_threadx.h
  group Application/LibModbus
    ../user/libmodbus/: modbus.c modbus.h modbus-data.c
  group Application/AT/Core
    ../user/at/core/: at_command_plan.c at_command_plan.h at_core.c at_core.h at_urc.c at_urc.h at_session.c at_session.h
  group Application/AT/Modules
    ../user/at/modules/: at_module.c at_module.h at_module_w800.c at_module_w800.h at_module_ec20.c at_module_ec20.h at_module_nearlink.c at_module_nearlink.h
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c app_usbx_device.c ux_device_cdc_acm.c
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/ThreadX/Core
    ../Middlewares/ST/threadx/common/src/: tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_resume.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group Middlewares/USBX/UX Device Controllers
    ../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/Core System
    ../Middlewares/ST/usbx/common/core/src/: ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/UX Device Class CDC ACM
    ../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_with_callback.c
software components: CMSIS:CORE 4.3.0
