/* Host regression tests for the Bootloader micro-ecc P-256 verifier. */
#include "uECC.h"

#include <stdint.h>
#include <stdio.h>
#include <string.h>

static const uint8_t test_public_key[64] =
{
    0x2E, 0xCF, 0x50, 0xB0, 0xBC, 0x6E, 0x2F, 0xB3,
    0x49, 0xFB, 0x63, 0x2E, 0xF9, 0x12, 0x63, 0x7B,
    0x47, 0x50, 0x6B, 0x39, 0xA7, 0x77, 0x08, 0xEE,
    0x5C, 0x13, 0x6B, 0x31, 0x71, 0x8F, 0xF6, 0xB3,
    0x9C, 0xCD, 0xA8, 0x07, 0x25, 0x9D, 0xD7, 0x24,
    0xB7, 0xAD, 0xFA, 0x15, 0x47, 0xA3, 0x35, 0xE5,
    0xCD, 0x21, 0xB0, 0x52, 0x48, 0x03, 0x2F, 0x6D,
    0x06, 0x83, 0xE8, 0x77, 0xDE, 0x8A, 0x39, 0x26
};

static const uint8_t test_digest[32] =
{
    0xCD, 0xE6, 0x4E, 0x81, 0xC3, 0xCA, 0xEF, 0x5D,
    0xDE, 0x95, 0xFC, 0x4E, 0xE9, 0x5F, 0xA5, 0x47,
    0x07, 0xCC, 0x50, 0x30, 0xE9, 0x79, 0xD4, 0xAE,
    0xD3, 0xFE, 0x6F, 0xB1, 0x52, 0x60, 0x03, 0x2D
};

static const uint8_t test_signature[64] =
{
    0xD6, 0x8C, 0x09, 0x70, 0xF5, 0x4A, 0x25, 0xCD,
    0x29, 0x2E, 0x14, 0x5F, 0x1D, 0xC7, 0xD0, 0xC1,
    0xA2, 0xF9, 0xA3, 0x31, 0xE3, 0x12, 0x08, 0x4D,
    0xAA, 0x63, 0x38, 0xB6, 0x59, 0x2E, 0xC0, 0x1F,
    0xA4, 0xD4, 0xDD, 0x72, 0x92, 0x89, 0x31, 0x42,
    0xA1, 0x6C, 0x42, 0x5F, 0xB6, 0x40, 0x12, 0xDF,
    0xD4, 0x4D, 0xAB, 0x9C, 0x54, 0xBC, 0xDD, 0xBE,
    0xB9, 0x85, 0x6A, 0xBA, 0x41, 0x2F, 0x6C, 0xD9
};

static int expect_invalid(const uint8_t digest[32], const uint8_t signature[64])
{
    return uECC_verify(test_public_key,
                       digest,
                       32U,
                       signature,
                       uECC_secp256r1()) == 0;
}

int main(void)
{
    uint8_t tampered_digest[32];
    uint8_t tampered_signature[64];

    if(uECC_verify(test_public_key,
                   test_digest,
                   sizeof(test_digest),
                   test_signature,
                   uECC_secp256r1()) != 1)
    {
        fputs("known signature rejected\n", stderr);
        return 1;
    }

    memcpy(tampered_digest, test_digest, sizeof(tampered_digest));
    tampered_digest[7] ^= 0x01U;
    if(!expect_invalid(tampered_digest, test_signature))
    {
        fputs("tampered digest accepted\n", stderr);
        return 2;
    }

    memcpy(tampered_signature, test_signature, sizeof(tampered_signature));
    tampered_signature[51] ^= 0x80U;
    if(!expect_invalid(test_digest, tampered_signature))
    {
        fputs("tampered signature accepted\n", stderr);
        return 3;
    }

    puts("OTA micro-ecc tests: all tests passed");
    return 0;
}
