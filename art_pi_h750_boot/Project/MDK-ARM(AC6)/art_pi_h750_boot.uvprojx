# Keil uVision project art_pi_h750_boot.uvprojx, settings and files
target Boot (6210000::V6.21::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x08000000-0x0801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: art_pi_h750_boot +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,uECC_PLATFORM=0,uECC_SUPPORTS_secp160r1=0,uECC_SUPPORTS_secp192r1=0,uECC_SUPPORTS_secp224r1=0,uECC_SUPPORTS_secp256r1=1,uECC_SUPPORTS_secp256k1=0,uECC_SUPPORT_COMPRESSED_POINT=0
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\User;..\..\..\art_pi_h750_common\gateway_ota;..\..\..\art_pi_h750_common\gateway_ota\micro_ecc;..\..\..\ARTPI\User\bsp\inc;..\..\..\ARTPI\User\bsp;..\..\..\ARTPI\Libraries\CMSIS\Include;..\..\..\ARTPI\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\ARTPI\Libraries\STM32H7xx_HAL_Driver\Inc
  asm define: TX_ENABLE_FPU_SUPPORT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\art_pi_h750_boot.sct
  group Boot
    ../../User/: boot_main.c boot_uart.c boot_uart.h boot_spi_flash.c boot_spi_flash.h boot_security.c boot_security.h
    ../../../ARTPI/User/bsp/src/: bsp_qspi_w25q128.c
    ../../../ARTPI/User/bsp/inc/: bsp_qspi_w25q128.h
    ../../../ARTPI/User/bsp/: stm32h7xx_hal_conf.h
    ../../../art_pi_h750_common/gateway_ota/: gateway_ota_format.h ota_sha256.c ota_sha256.h
    ../../../art_pi_h750_common/gateway_ota/micro_ecc/: uECC.c uECC.h
  group HAL_Driver
    ../../../ARTPI/Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c
    ../../User/: boot_control.c boot_control.h
  group CMSIS
    ../../../ARTPI/Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../User/: startup_stm32h750xx_boot.s
