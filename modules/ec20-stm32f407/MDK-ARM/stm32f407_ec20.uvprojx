# Keil uVision project stm32f407_ec20.uvprojx, settings and files
target stm32f407_ec20 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_ec20 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../app;../bsp;../mid;../leduo;../dht11;..\tlsf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group bsp
    ../bsp/: bsp_timer.c bsp_timer.h bsp_usart.c bsp_usart.h log.h bsp_rtc.c bsp_rtc.h
  group mid
    ../mid/: liqueue.c liqueue.h cJSON.c cJSON.h
  group app
    ../app/: debug_config.c debug_config.h debug_task.c module_config.c module_config.h module_task.c ec20_drv.c ec20_drv.h ec20_lib.c ec20_lib.h ec20_network.c ec20_network.h ec20_mqtt.c ec20_mqtt.h ec20_pub.c ec20_pub.h timer_task.c timer_task.h w25qxx.c w25qxx.h app_flashlite.c app_flashlite.h app_flashid.c app_flashid.h app_at_frame.c app_at_frame.h app_cmd.c app_cmd.h rs485_config.c rs485_config.h rs485_task.c app_gather.c app_gather.h app_info.c app_info.h app_dht11.c app_dht11.h app_pub_onenet.c app_pub_onenet.h app_server.c app_server.h app_tlsf.c app_tlsf.h
  group leduo
    ../leduo/: leduo.c leduo.h
  group tlsf
    ../tlsf/: tlsf.c tlsf.h
software components: CMSIS:CORE 5.3.0
