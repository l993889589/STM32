# Keil uVision project STM32H563_Modbus.uvprojx, settings and files
target STM32H563_Modbus (6210000::V6.21::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x081FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H563_Modbus +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../user/app;../user/bsp;../user/ldc/core;../user/osal;../user/transport;../Middlewares/ld_modbus/include;../Middlewares/ld_modbus/integrations/ldc
  asm define: USE_HAL_DRIVER,STM32H563xx
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Core
    ../Core/Src/: main.c gpio.c dcache.c icache.c stm32h5xx_it.c stm32h5xx_hal_msp.c
    ../user/app/: modbus_app.c
    ../Middlewares/ld_modbus/src/: ld_modbus_core.c ld_modbus_server.c
    ../Middlewares/ld_modbus/integrations/ldc/: ld_modbus_ldc.c
  group BSP
    ../user/bsp/: bsp.c bsp_diagnostics.c
  group BSP/STM32H5
    ../Core/Src/: system_stm32h5xx.c
    ../user/bsp/: bsp_clock_stm32h5.c bsp_fdcan_stm32h5.c bsp_i2c_stm32h5.c bsp_critical_stm32h5.c bsp_fault_stm32h5.c bsp_pwm_stm32h5.c bsp_spi_stm32h5.c bsp_time_stm32h5.c bsp_uart_stm32h5.c
  group BSP/Board
    ../user/bsp/: board_init.c board_control.c board_fdcan.c board_i2c.c board_led.c board_pwm.c board_rtc.c board_spi.c board_uart.c board_usb_device.c
  group BSP/Drivers
    ../user/bsp/: drv_gd25lq128.c drv_ft6336.c drv_st7796.c drv_w800.c
  group Application/LDC
    ../user/ldc/core/: ldc_core.c ldc_easy.c ldc_packet.c ldc_ring.c
  group Application/Transport
    ../user/transport/: transport_uart_ldc.c
  group Application/OSAL
    ../user/osal/: osal_bare_metal.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
